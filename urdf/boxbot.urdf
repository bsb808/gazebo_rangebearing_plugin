Commit message: working version with no noise

File: urdf/boxbot.urdf (robot description, URDF)
Before this commit: robot boxbot, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.3 0.1 0.01; visual box size=0.3 0.1 0.01
